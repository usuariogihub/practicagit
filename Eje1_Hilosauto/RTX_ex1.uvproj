# Keil uVision project RTX_ex1.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RTX_ex1 +hex
  c flags: Optim=1
  c include: ..\..\..\INC
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ./src/: startup_LPC17xx.s system_LPC17xx.c
  group RTX Configuration
    ./src/: RTX_Conf_CM.c
  group RTX Library
    ./src/: RTX_CM3.lib
  group Source Files
    ./src/: RTX_ex1.c
  group Documentation
    ../: Abstract.txt
